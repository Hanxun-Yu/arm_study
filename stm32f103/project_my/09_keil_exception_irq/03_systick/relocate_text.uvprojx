# Keil uVision project relocate_text.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: relocate_text +hex
  AfterMake: fromelf  --bin  --output=huibian.bin  Objects\relocate_text.axf
  AfterMake: fromelf  --text  -a -c  --output=huibian.dis  Objects\relocate_text.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\relocate_text.sct
  group main
    ./: main.c print.c print.h uart.c uart.h led.c led.h
  group cpu
    ./: start.s
  group init
    ./: init.c
  group exception
    ./: exception.c exception.h systick.c systick.h
